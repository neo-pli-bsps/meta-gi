KV = "4.1.37"
GCCREV = "6.2.0"
SRCDATE = "20170712"

require et1x000-dvb-modules.inc

SRC_URI[md5sum] = "111f541d421755119fbc92b0561d17c8"
SRC_URI[sha256sum] = "a04ffad1b80f0f4eefc0f98f891a2c79f8e853950896657b601abd9cf793e4c0"
